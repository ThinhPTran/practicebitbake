DESCRIPTION = "I am the first recipe"
PR = "r1"
do_build () {
  echo "First: some shell script running as build"
}
